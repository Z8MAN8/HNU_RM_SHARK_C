# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, ARM_MATH_CM4
  c include: src\algorithm\arm_math;src\modules\imu;src\algorithm\user_lib;src\modules\msg;src\task;.;src\modules\mag;src\task\ins;rt-thread\include;src\modules\mag\ist8310;rt-thread\components\libc\compilers\common\include;src\algorithm\kalman_filter;src\task\motor;src\modules\rc\sbus;rt-thread\components\libc\posix\io\poll;src\algorithm;rt-thread\libcpu\arm\cortex-m4;src\algorithm\pid;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;src\modules\dwt;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;src\modules\motor\DJI_motor;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;applications;libraries\HAL_Drivers;src\modules;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;src\algorithm\QuaternionEKF;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;board;rt-thread\components\libc\posix\io\eventfd;rt-thread\libcpu\arm\common;src\modules\imu\bmi088;src;rt-thread\components\drivers\include;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\HAL_Drivers\config;src\modules\motor;src\task\example;rt-thread\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_can.c drv_common.c drv_gpio.c drv_pwm.c drv_soft_i2c.c drv_spi.c drv_tim.c drv_usart.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group RM_Algorithms
    src/algorithm/kalman_filter/: kalman_filter.c
    src/algorithm/QuaternionEKF/: QuaternionEKF.c
    src/algorithm/user_lib/: user_lib.c
    src/algorithm/pid/: pid.c
  group RM_Modules
    src/modules/rc/sbus/: rc_sbus.c
    src/modules/imu/bmi088/: bmi088.c
    src/modules/msg/: drv_msg.c
    src/modules/dwt/: drv_dwt.c
    src/modules/motor/DJI_motor/: dji_motor.c
    src/modules/mag/ist8310/: ist8310.c
    src/modules/: usr_callback.c
  group RM_Task
    src/task/motor/: motor_task.c
    src/task/example/: example_task.c
    src/task/: robot.c
    src/task/ins/: ins_task.c
